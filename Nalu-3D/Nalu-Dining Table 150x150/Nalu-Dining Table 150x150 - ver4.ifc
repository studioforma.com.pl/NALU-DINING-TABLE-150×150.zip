Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Dining Table 150x150 - ver4.ifc
Time: 2024-10-24T08:30:40
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (92)
Name
 | Nalu-Dining Table 150x150_0 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_1 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_2 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_3 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_4 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_5 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_6 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_7 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_8 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_9 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_10 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_11 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_12 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_13 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_14 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_15 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_16 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_17 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_18 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_19 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_20 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_21 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_22 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_23 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_24 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_25 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_26 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_27 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_28 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_29 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_30 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_31 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_32 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_33 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_34 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_35 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_36 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_37 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_38 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_39 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_40 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_41 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_42 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_43 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_44 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_45 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_46 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_47 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_48 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_49 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_50 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_51 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_52 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_53 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_54 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_55 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_56 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_57 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_58 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_59 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_60 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_61 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_62 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_63 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_64 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_65 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_66 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_67 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_68 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_69 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_70 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_71 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_72 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_73 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_74 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_75 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_76 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_77 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_78 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_79 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_80 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_81 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_82 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_83 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_84 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_85 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_86 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_87 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_88 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_89 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_90 - ObjectType: SketchupGroup
 | Nalu-Dining Table 150x150_91 - ObjectType: SketchupGroup
